# Keil uVision project DensityInspection.uvproj, settings and files
target DebugInFlash (ARM-ADS)
  device: LPC1114/302 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: DensityInspection
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group CMSIS Files
    ./LPC11xx/: system_LPC11xx.c
    ./LPC11xx/startup/: startup_LPC11xx.s
  group USER_CODE
    ./USER_CODE/: main.c
